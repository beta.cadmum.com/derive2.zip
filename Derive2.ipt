# Autodesk Inventor part: Derive2
## iProperties
Created: 2008-08
Part Number: Derive2
Document SubType Name: Modeling
Designer: JWe
Density: 1 g/cm^3
Author: JWe
## Feature names
1. Extrusion1
